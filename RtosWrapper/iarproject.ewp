# IAR project iarproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Rtos; Rtos\wrapper; Rtos\wrapper\FreeRtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable; Rtos\FreeRtos\portable\Common; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\FreeRtos\portable\MemMang; MyTasks; Common; CMSIS; Application; Application\Diagnostic; AHardware; AHardware\GpioPort; AHardware\IrqController; ..\CortexLib\AbstractHardware\Pin; ..\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; ..\CortexLib\AbstractHardware\Registers\STM32F411; ..\CortexLib\AbstractHardware\Registers; ..\CortexLib\AbstractHardware\Port; ..\CortexLib\AbstractHardware\Atomic; ..\CortexLib\Common; ..\CortexLib\Common\Singleton; ..\CortexLib\Common\RomObject; Application\Implementation; Application\Contracts; Application\Implementation\Modes; D:\RtosWrapper\minor-labs\repo\RtosWrapper\Application\Implementation
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\wrapper\FreeRtos; Rtos\wrapper; Application\Contracts
  OBJCOPY.OOCOutputFile: iarproject.srec
  ILINK.IlinkOutputFile: iarproject.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp startupF411RE.cpp
  group Application/Contracts
    Application/Contracts/: iadcmanager.h ibutton.h idataprovider.h ifilter.h iledtoggleable.h imode.h imodemanager.h
  group Application/Implementation
    Application/Implementation/: adc.h button.h led.h modemanager.h modes.h TemperatureFilter.cpp TemperatureFilter.h
  group Application/Implementation/Modes
    Application/Implementation/Modes/: chessmode.h treemode.h
  group MyTasks
    MyTasks/: ButtonTask.cpp ButtonTask.h LedManagerTask.cpp LedManagerTask.hpp MeasureTask.cpp MeasureTask.hpp
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/portable/Common
    Rtos/FreeRtos/portable/Common/: mpu_wrappers.c
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.c portasm.s
  group Rtos/FreeRtos/portable/MemMang
    Rtos/FreeRtos/portable/MemMang/: heap_1.c
  group Rtos/wrapper/FreeRtos
    Rtos/wrapper/: criticalsection.hpp event.hpp eventmode.hpp interruptentry.hpp mailbox.hpp mutex.hpp rtos.hpp thread.hpp
